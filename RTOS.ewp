# IAR project RTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: XMC4500-F100x1024 Infineon XMC4500-F100x1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: Startup; Include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.3\arm\CMSIS\Include; OS\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: RTOS.out
  ILINK.IlinkIcfFile: RTOS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Include
    Include/: CLK001.h GPIO.h system_XMC4500.h XMC4500.h
  group OS/inc
    OS/inc/: List.h OS.h OS_Cfg.h Port.h Task.h
  group OS/src
    OS/src/: List.c OS.c Port.c port_asm.s Task.c
  group Sources
    Sources/: CLK001.c GPIO.c main.c System_XMC4500.c
  group Startup
    Startup/: startup_XMC4500.s
